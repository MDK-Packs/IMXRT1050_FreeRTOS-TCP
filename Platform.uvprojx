# Keil uVision project Platform.uvprojx, settings and files
target AWS_Demo (6160000::V6.16::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.13.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MBEDTLS_CONFIG_FILE=\"aws_mbedtls_config.h\" MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h ENABLE_IOT_INFO ENABLE_IOT_ERROR SENSOR RFU USE_OFFLOAD_SSL SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED, SKIP_SYSCLK_INIT, VIO_SENSOR_DISABLE
  c misc: -Wno-pragma-pack
  c include: .\;.\BSP;.\config_files;.\amazon-freertos\libraries\c_sdk\standard\common\include\private;.\amazon-freertos\libraries\c_sdk\standard\common\include;.\amazon-freertos\libraries\logging\include;.\amazon-freertos\libraries\freertos_plus\standard\crypto\include;.\amazon-freertos\libraries\freertos_plus\standard\tls\include;.\amazon-freertos\libraries\abstractions\platform\include;.\amazon-freertos\libraries\abstractions\platform\freertos\include;.\amazon-freertos\libraries\abstractions\platform\include\platform;.\amazon-freertos\libraries\abstractions\secure_sockets\include;.\amazon-freertos\libraries\abstractions\transport\secure_sockets;.\amazon-freertos\libraries\abstractions\wifi\include;.\amazon-freertos\demos\include;.\amazon-freertos\demos\network_manager;.\amazon-freertos\demos\common\pkcs11_helpers
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1052DVL6B\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group App
    ./: app_main.c network_startup.c
  group Board
    ./: main.c main.h
  group Board_IO
    ./Board_IO/: retarget_stdio.c
  group MCUXpresso
    ./: IMXRT1050-EVKB.mex
  group Documentation
    ./: README.md
  group coreMQTT demo
    ./amazon-freertos/demos/demo_runner/: aws_demo.c iot_demo_runner.c iot_demo_freertos.c
    ./amazon-freertos/demos/coreMQTT/: mqtt_demo_mutual_auth.c
    ./amazon-freertos/demos/common/pkcs11_helpers/: pkcs11_helpers.c
    ./amazon-freertos/demos/network_manager/: aws_iot_network_manager.c
  group libraries_abstractions_platform_freertos
    ./amazon-freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_threads_freertos.c
  group libraries_abstractions_transport_secure_sockets
    ./amazon-freertos/libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c
  group libraries_c_sdk_standard_common
    ./amazon-freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group libraries_c_sdk_standard_common_taskpool
    ./amazon-freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries_logging
    ./amazon-freertos/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group libraries_freertos_plus_standard_crypto
    ./amazon-freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries_freertos_plus_standard_tls
    ./amazon-freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group AWS_BSP
    ./BSP/: core_pkcs11_pal.c iot_secure_sockets.c NetworkInterface.c
software components: RTOS:Config 10.4.3, RTOS:Core 10.4.3, RTOS:Event Groups 10.4.3, RTOS:Heap 10.4.3, RTOS:Stream Buffer 10.4.3, RTOS:Timers 10.4.3, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.4.3, Security:mbed TLS 2.24.0, FreeRTOS:FreeRTOS+ TCP:Buffer Management 2.3.2, FreeRTOS:FreeRTOS+ TCP:Compiler Port 2.3.2, FreeRTOS:FreeRTOS+ TCP:Core Library 2.3.2, FreeRTOS:FreeRTOS+ TCP:Network Interface 2.3.2, FreeRTOS:backoffAlgorithm 1.0.0, FreeRTOS:coreMQTT Agent 1.0.1, FreeRTOS:coreMQTT 1.1.0, FreeRTOS:corePKCS11 3.0.0, Security:PKCS11 , Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:Ethernet MAC 1.2.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.3.0, CMSIS Driver:VIO:Board 1.0.1, Board Support:SDK Drivers:evkbimxrt1050 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis 2.2.0, Device:CMSIS:MIMXRT1052_header 1.0.0, Device:CMSIS:MIMXRT1052_system 1.0.0, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:common 2.3.0, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:edma 2.4.2, Device:SDK Drivers:enet 2.5.0, Device:SDK Drivers:fxos8700cq 1.0.0, Device:SDK Drivers:gpio 2.0.5, Device:SDK Drivers:i2c 2.3.0, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.5.1, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.5.0, Device:SDK Drivers:nic301 2.0.0, Device:SDK Drivers:sdhc 2.8.0, Device:SDK Drivers:xip_device 2.0.2, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
